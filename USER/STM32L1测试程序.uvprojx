# Keil uVision project STM32L1测试程序.uvprojx, settings and files
target STM32L1测试程序 (ARM-ADS)
  device: STM32L152CC STMicroelectronics
  pack: Keil.STM32L1xx_DFP.1.2.0
  cpu: IROM(0x08000000,0x00040000) IRAM(0x20000000,0x00008000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: STM32L1测试程序 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L1XX_MDP,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\STM32L1xx_FWLib\inc;..\USER;..\HARDWARE\DELAY;..\HARDWARE\LED;..\HARDWARE\TIM3;..\Gizwits;..\Utils;..\HARDWARE\USART2;..\HARDWARE\Buzzer;..\HARDWARE\GPRS-ON;..\HARDWARE\USART3;..\HARDWARE\adc;..\HARDWARE\OLED;..\HARDWARE\OLED\font;..\HARDWARE\SHT20;..\HARDWARE\TIM2forGHT;..\HARDWARE\BUTTON;..\HARDWARE\TIM4forBUTTON;..\HARDWARE\WEIGH;..\HARDWARE\TIM6forSHOINGWATER;..\HARDWARE\TIM7forLED;..\HARDWARE\WEIGH;..\HARDWARE\TIM5forG510ONandOFF;..\HARDWARE\TIM9forLEDandBUZZER;..\HARDWARE\RTC;..\HARDWARE\TIM10forReminding_of_drinking;..\HARDWARE\Battery_Charge_Status
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group USER
    ./: main.c stm32l1xx_it.c system_stm32l1xx.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32l1xx_mdp.s
  group FWLIB
    ../STM32L1xx_FWLib/src/: misc.c stm32l1xx_adc.c stm32l1xx_aes.c stm32l1xx_aes_util.c stm32l1xx_comp.c stm32l1xx_crc.c stm32l1xx_dac.c stm32l1xx_dbgmcu.c stm32l1xx_dma.c stm32l1xx_exti.c stm32l1xx_flash.c stm32l1xx_flash_ramfunc.c stm32l1xx_fsmc.c stm32l1xx_gpio.c stm32l1xx_i2c.c stm32l1xx_iwdg.c stm32l1xx_lcd.c stm32l1xx_opamp.c stm32l1xx_pwr.c stm32l1xx_rcc.c stm32l1xx_rtc.c stm32l1xx_sdio.c stm32l1xx_spi.c stm32l1xx_syscfg.c stm32l1xx_tim.c stm32l1xx_usart.c stm32l1xx_wwdg.c
  group HARDWARE
    ../HARDWARE/DELAY/: delay.c
    ../HARDWARE/LED/: led.c
    ../HARDWARE/TIM3/: tim3.c
    ../HARDWARE/WEIGH/: weigh.c
    ../HARDWARE/USART2/: usart2.c
    ../HARDWARE/Buzzer/: buzzer.c
    ../HARDWARE/GPRS-ON/: gprson.c
    ../HARDWARE/USART3/: usart3.c
    ../HARDWARE/adc/: bsp_adc.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/SHT20/: SHT20.c
    ../HARDWARE/TIM2forGHT/: tim2forght.c
    ../HARDWARE/BUTTON/: button.c
    ../HARDWARE/TIM4forBUTTON/: tim4forbutton.c
    ../HARDWARE/TIM6forSHOINGWATER/: tim6forshowingwater.c
    ../HARDWARE/TIM7forLED/: tim7forled.c
    ../HARDWARE/RTC/: rtc.c
    ../HARDWARE/TIM9forLEDandBUZZER/: tim9forledandbuzzer.c
    ../HARDWARE/TIM5forG510ONandOFF/: tim5forg510onandoff.c
    ../HARDWARE/TIM10forReminding_of_drinking/: tim10_for_reminding_of_drinking.c
    ../HARDWARE/Battery_Charge_Status/: battery_charge_status.c
  group Gizwits
    ../Gizwits/: gizwits_product.c gizwits_protocol.c
    ../Utils/: common.c dataPointTools.c ringbuffer.c
